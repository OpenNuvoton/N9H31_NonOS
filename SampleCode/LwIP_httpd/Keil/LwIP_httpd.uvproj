# Keil uVision project LwIP_httpd.uvproj, settings and files
target LwIP_httpd (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: LwIP_httpd
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c misc: --diag_suppress=1295,177,550
  c include: ..\..\..\Driver\Include;..\lwip-1.4.1\include;..\..\..\ThirdParty\lwip-1.4.1\src\include\ipv4;..\..\..\ThirdParty\lwip-1.4.1\src\include\
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H31.sct
  link misc: --entry 0
  group src
    ../: main.c
  group Libraries
    ../../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c system_N9H31.c startup_N9H31.s sys_N9H31.s
  group LwIP
    ../lwip-1.4.1/netif/: ethernetif.c n9h31_eth0.c n9h31_eth1.c
    ../../../ThirdParty/lwip-1.4.1/src/netif/: etharp.c
    ../../../ThirdParty/lwip-1.4.1/src/core/: dhcp.c init.c mem.c memp.c netif.c pbuf.c tcp.c tcp_in.c tcp_out.c udp.c def.c timers.c
    ../../../ThirdParty/lwip-1.4.1/src/core/ipv4/: icmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.4.1/: sys_arch.c
