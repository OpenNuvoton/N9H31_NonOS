# Keil uVision project ETIMER_FreeCounting.uvproj, settings and files
target ETIMER_FreeCounting (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: ETIMER_FreeCounting
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\Driver\Include
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H31.sct
  link misc: --entry 0
  group src
    ../: main.c
  group Libraries
    ../../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c system_N9H31.c startup_N9H31.s sys_N9H31.s etimer.c
