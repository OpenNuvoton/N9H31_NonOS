# Keil uVision project USBD_Mass_Storage_NAND.uvproj, settings and files
target USBD_Mass_Storage_NAND (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: USBD_Mass_Storage_NAND
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1
  c include: ..\..\..\Driver\Include;..\..\..\Library\GNandLib\Include
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H31.sct
  link misc: --entry 0
  group User
    ../: descriptors.c main.c MassStorage.c
  group Libraries
    ../../../Driver/Source/: sys.c usbd.c standalone.c sys_timer.c sys_uart.c startup_N9H31.s sys_N9H31.s system_N9H31.c
  group GNandLib
    ../../../Library/GNandLib/: GNandLib_Keil.lib nand.c
