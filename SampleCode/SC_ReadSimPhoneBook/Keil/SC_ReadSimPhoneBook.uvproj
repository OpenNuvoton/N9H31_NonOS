# Keil uVision project SC_ReadSimPhoneBook.uvproj, settings and files
target SC_ReadSimPhoneBook (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SC_ReadSimPhoneBook
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3
  c include: ..\..\..\Driver\Include;..\..\..\Library\SmartcardLib\Include
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H31.sct
  link misc: --entry 0
  group src
    ../: main.c
  group Libraries
    ../../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c system_N9H31.c startup_N9H31.s sys_N9H31.s sc.c
    ../../../Library/SmartcardLib/: SmartCardLib_Keil.lib
