# Keil uVision project I2S_MP3Player.uvproj, settings and files
target I2S_MP3Player (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: I2S_MP3Player
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 wLevel=1
  c define: __WINS__ OPT_SPEED
  c include: ..\..\..\Driver\Include;..\..\..\ThirdParty\FatFs\source;..\..\..\ThirdParty\LibMAD\inc
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H31.sct
  link misc: --entry 0
  group User
    ../: main.c diskio.c SDGlue.c mp3.c MP3HeaderParser.c
  group Libraries
    ../../../Driver/Source/: i2c.c i2s.c standalone.c sys.c sys_timer.c sys_uart.c sdh.c system_N9H31.c startup_N9H31.s sys_N9H31.s
  group FatFs
    ../../../ThirdParty/FatFs/source/: ff.c
  group MP3Lib
    ../../../ThirdParty/LibMAD/src/: bit.c decoder.c fixed.c frame.c huffman.c layer3.c layer12.c MP3Func.c stream.c synth.c timer.c version.c
