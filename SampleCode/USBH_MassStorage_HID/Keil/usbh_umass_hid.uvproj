# Keil uVision project usbh_umass_hid.uvproj, settings and files
target usbh_usbh_mass (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: usbh_umass_hid
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: NO_TIMER, IS_FPGA
  c include: ..\..\..\Driver\Include;..\..\..\Library\UsbHostLib\inc;..\..\..\ThirdParty\FATFS\source
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x2000000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H31.sct
  link misc: --entry 0
  group src
    ../: diskio.c main.c
  group src_usb_core
    ../../../Library/UsbHostLib/src_core/: ehci.c ehci_iso.c hub.c mem_alloc.c ohci.c usb_core.c support.c
  group src_usb_umas
    ../../../Library/UsbHostLib/src_msc/: msc_driver.c msc_xfer.c
  group src_fatfs
    ../../../ThirdParty/FatFs/source/: ff.c
  group Libraries
    ../../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c startup_N9H31.s sys_N9H31.s system_N9H31.c
  group src_usb_hid
    ../../../Library/UsbHostLib/src_hid/: hid_core.c hid_driver.c
