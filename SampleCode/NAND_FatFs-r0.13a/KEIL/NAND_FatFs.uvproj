# Keil uVision project NAND_FatFs.uvproj, settings and files
target NAND_FatFs (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NAND_FatFs-r0.13a
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1
  c include: ..\..\..\Driver\Include;..\..\..\Library\GNandLib\Include;..\..\..\ThirdParty\FatFs-r0.13a\source
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H31.sct
  link misc: --entry 0
  group User
    ../: main.c diskio.c
  group Libraries
    ../../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c startup_N9H31.s sys_N9H31.s system_N9H31.c
  group GNandLib
    ../../../Library/GNandLib/: GNandLib_Keil.lib nand.c
  group FatFs
    ../../../ThirdParty/FatFs-r0.13a/source/: ff.c
