# Keil uVision project NandLib.uvproj, settings and files
target NandLib (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: GNandLib_Keil (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\GNANDLib
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Driver\Include;..\..\GNandLib\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source
    ../: nandlib_access.c nandlib_init.c nandlib_p2l.c
