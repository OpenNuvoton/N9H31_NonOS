# Keil uVision project NVTLoader.uvproj, settings and files
target NAND_NVTLoader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NVT_NAND_Loader
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Driver\Include;..\..\..\Library\GNandLib\Include;..\..\..\ThirdParty\FatFs\source
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_NVTLoader.scf
  link misc: --entry Reset_Go
  group Src
    ../: heap.s main.c stack.s standalone.c vectors.s diskio.c descriptors.c MassStorage.c sys_init.s
  group Libraries
    ../../../Library/GNandLib/: GNandLib_Keil.lib nand.c
    ../../../Driver/Source/: fmi.c gpio.c lcd.c sys.c sys_timer.c sys_uart.c usbd.c sys_N9H31.s system_N9H31.c
  group Fatfs
    ../../../ThirdParty/FatFs/source/: ff.c
target N9H20K5_SD_GPM1006D0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NVT_SDU0_GPM1006D0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__ __ENABLE_SD_CARD_0__ N9H20K5
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K5_NAND_FW043TFT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NVT_NAND_FW043TFT
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __GWMT9360A__ __LCM_480x272__ N9H20K5
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K5_SD_FW043TFT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NVT_SDU0_FW043TFT
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __GWMT9360A__ __LCM_480x272__ __ENABLE_SD_CARD_0__ N9H20K5
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K5_NAND_FW050TFT_800x480 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NVT_NAND__FW050TFT
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __GWMT9360A__ __LCM_800x480__ N9H20K5
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K5_SD_FW050TFT_800x480 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NVT_SDU0_FW050TFT
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __GWMT9360A__ __LCM_800x480__  __ENABLE_SD_CARD_0__ N9H20K5
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K5_SPI_GPM1006D0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NVT_SPI_GPM1006D0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__ N9H20K5 __SPI_ONLY__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K5_SPI_FW043TFT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NVT_SPI_FW043TFT
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __GWMT9360A__ __LCM_480x272__ N9H20K5 __SPI_ONLY__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K5_SPI_FW050TFT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NVT_SPI_FW050TFT
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __GWMT9360A__ __LCM_800x480__ N9H20K5 __SPI_ONLY__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K5.scf
  link misc: --entry Reset_Go
